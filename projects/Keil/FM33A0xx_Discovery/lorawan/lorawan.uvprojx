# Keil uVision project lorawan.uvprojx, settings and files
target debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: FM33A04XX FMSH
  pack: Keil.FM33A0XX_DFP.0.2.02
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: helloword
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __DEBUG,CONFIG_NO_TCPIP,AOS_KV,BUILD_KERNEL,AOS_LOOP,CONFIG_AOS_CLI,AOS_LOOP,AOS_VFS
  c include: ..\..\..\..\include;..\..\..\..\include\aos;..\..\..\..\kernel\rhino\core\include;..\..\..\..\platform\arch\arm\armv6m\armcc\m0;..\..\..\..\platform\mcu\fm33A0xx\Drivers;..\..\..\..\platform\mcu\fm33A0xx\Device\Include;..\..\..\..\include\hal;..\..\..\..\platform\mcu\fm33A0xx\aos;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\board\fm33a0xx-discovery;..\..\..\..\include\aos\internal;..\..\..\..\kernel\modules\fs\fatfs\include;..\..\..\..\kernel\modules\fs\fatfs\ff\include;..\..\..\..\kernel\modules\mm;..\..\..\..\kernel\modules\mm\tlsf;..\..\..\..\kernel\vfs\include;..\..\..\..\kernel\vfs\include\device;..\..\..\..\kernel\yloop;..\..\..\..\include\aos\internal;..\..\..\..\kernel\vcall\aos;..\..\..\..\kernel\vcall\cmsis;..\..\..\..\kernel\vcall\espos\include;..\..\..\..\kernel\vcall\espos\include\arch;..\..\..\..\kernel\vcall\mico\include;..\..\..\..\kernel\modules\fs\kv\include;..\..\..\..\test\yunit\include;..\..\..\..\test\testcase\include;..\..\..\..\tools\cli;..\..\..\..\include\hal\soc;..\..\..\..\platform\mcu\fm33A0xx..\..\..\..\include\aos\internal;..\..\..\..\device\lora\eml3047_lrwan;..\..\..\..\device\lora\sx1276;..\..\..\..\kernel\protocols\lorawan\linkwan;..\..\..\..\kernel\protocols\lorawan\linkwan\include;..\..\..\..\kernel\protocols\lorawan\lora\mac;..\..\..\..\kernel\protocols\lorawan\lora\radio;..\..\..\..\kernel\protocols\lorawan\lora\system;..\..\..\..\platform\mcu\fm33A0xx\aos_rhino;..\..\..\..\kernel\protocols\lorawan\lora\mac\region
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group platform\mcu\fm33a0xx\Drivers
    ../../../../platform/mcu/fm33A0xx/Drivers/: fm33a0xx_aes.c fm33a0xx_anac.c fm33a0xx_btim.c fm33a0xx_crc.c fm33a0xx_dma.c fm33a0xx_etim.c fm33a0xx_flash.c fm33a0xx_gpio.c fm33a0xx_hspi.c fm33a0xx_i2c.c fm33a0xx_iwdt.c fm33a0xx_lcd.c fm33a0xx_lptim.c fm33a0xx_pmu.c fm33a0xx_rcc.c fm33a0xx_rtc.c fm33a0xx_scu.c fm33a0xx_spi.c fm33a0xx_trng.c fm33a0xx_u7816.c fm33a0xx_uart.c fm33a0xx_wwdt.c
  group platform\mcu\fm33a0xx\Device
    ../../../../platform/mcu/fm33A0xx/Device/Source/: system_FM33A0XX.c
    ../../../../platform/mcu/fm33A0xx/Device/Source/ARM/: startup_FM33A0XX.s
  group platform\mcu\fm33a0xx\Hal
    ../../../../platform/mcu/fm33A0xx/HAL/soc/: adc.c flash.c gpio.c i2c.c interpt.c nand.c nor.c pwm.c qspi.c rng.c rtc.c sd.c spi.c timer.c uart.c wdg.c
  group platform\mcu\fm33a0xx
    ../../../../platform/mcu/fm33A0xx/aos/: soc_init.c soc_impl.c
    ./../../../../platform/mcu/fm33A0xx/aos/: aos.c
  group kernel\rhino\core
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group utility\libc\compilers\armlibc
    ../../../../utility/libc/compilers/armlibc/: armcc_libc.c
  group platform\arch\arm\armv7m\armcc\m0
    ../../../../platform/arch/arm/armv6m/armcc/m0/: port_c.c port_s.S
  group example
    ../../../../example/rhinorun/: rhinorun.c
    ../../../../example/lorawan/linkwan/: linkwan.c
  group device\lora
    ../../../../device/lora/sx1276/: sx1276.c
    ../../../../device/lora/eml3047_lrwan/: eml3047.c
  group kernal\protocols\lorawan\lora
    ../../../../kernel/protocols/lorawan/lora/mac/: LoRaMac.c LoRaMacCrypto.c
    ../../../../kernel/protocols/lorawan/lora/mac/region/: Region.c RegionCN470.c RegionCommon.c
    ../../../../kernel/protocols/lorawan/lora/system/: delay.c low_power.c timeServer.c utilities.c
    ../../../../kernel/protocols/lorawan/lora/system/crypto/: aes.c cmac.c
target realse (ARM-ADS)
  device: FM33A03XX FMSH
  pack: Keil.FM33A0XX_DFP.0.2.02
  cpu: IROM(0x00000000,0x30000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: helloword
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x4000
